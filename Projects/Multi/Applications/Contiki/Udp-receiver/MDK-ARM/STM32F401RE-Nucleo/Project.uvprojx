# Keil uVision project Project.uvprojx, settings and files
target STM32F401RE_Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: udp-receiver_f401 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1
  c define: X_NUCLEO_IDS01A4,STM32F401xE,USE_USART2,USE_STM32F4XX_NUCLEO,USE_HAL_DRIVER,HSE_VALUE=84000000ul,USE_STDPERIPH_DRIVER,NO_EEPROM,SPIRIT1_ST_SHIELD,SPIRIT_MODULE,USE_SPIRIT1_DEFAULT,WITH_UIP6,IAR_ARM_CM3,VECT_TAB_FLASH,WITH_UIP,WITH_ASCII,CONTIKI=1,UIP_CONF_TCP=1,NETSTACK_CONF_WITH_IPV6=1,UIP_CONF_IPV6_RPL=1,AUTOSTART_ENABLE=1,PROJECT_CONF_H=1,
  c misc: --C99 --gnu  --diag-suppress=188  --diag-suppress=1295
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\..\Drivers\BSP\STM32F4xx_Nucleo;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc;..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library;..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\Inc;..\..\..\..\..\..\..\Middlewares\ST\Contiki_STM32_Library\dev;..\..\..\..\..\..\..\Drivers\BSP\Components\;..\..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc;..\..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\sys;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\dev;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ip;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\ipv6;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\llsec;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\net\rpl;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\core\lib;..\..\..\..\..\..\..\Middlewares\Third_Party\Contiki\apps\servreg-hack
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/SPIRIT1
    ../../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_rtc_ex.c
  group Example/MDK-ARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Example/User
    ../../Src/: cube_hal_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c unicast-receiver.c
  group Middlewares/Contiki/apps/servreg-hack
    ../../../../../../../Middlewares/Third_Party/Contiki/apps/servreg-hack/: servreg-hack.c
  group Middlewares/Contiki/core/lib
    ../../../../../../../Middlewares/Third_Party/Contiki/core/lib/: list.c memb.c random.c sensors.c
  group Middlewares/Contiki/core/net
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/: linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c link-stats.c net-debug.c
  group Middlewares/Contiki/core/net/ip
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/ip/: ip64-addr.c psock.c resolv.c simple-udp.c tcpip.c tcp-socket.c udp-socket.c uip-debug.c uiplib.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c
  group Middlewares/Contiki/core/net/ipv6
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/ipv6/: sicslowpan.c uip6.c uip-ds6.c uip-ds6-nbr.c uip-ds6-route.c uip-icmp6.c uip-nd6.c
  group Middlewares/Contiki/core/net/llsec
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group Middlewares/Contiki/core/net/mac
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/mac/: csma.c frame802154.c frame802154e-ie.c framer-802154.c framer-nullmac.c mac.c mac-sequence.c nordc.c nullmac.c nullrdc.c nullrdc-noframer.c phase.c
  group Middlewares/Contiki/core/net/rpl
    ../../../../../../../Middlewares/Third_Party/Contiki/core/net/rpl/: rpl.c rpl-dag.c rpl-dag-root.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl-nbr-policy.c rpl-ns.c
  group Middlewares/Contiki/core/sys
    ../../../../../../../Middlewares/Third_Party/Contiki/core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c process.c procinit.c rtimer.c stimer.c timer.c
  group Middlewares/Contiki_STM32_Library
    ../../../../../../../Middlewares/ST/Contiki_STM32_Library/dev/: button-sensor.c leds-arch.c radio-sensor.c
    ../../../../../../../Middlewares/ST/Contiki_STM32_Library/Src/: clock.c console.c contiki-spirit1-main.c node-id.c rtimer-arch.c spirit1.c spirit1-arch.c watchdog.c
  group Middlewares/Contiki/core/dev
    ../../../../../../../Middlewares/Third_Party/Contiki/core/dev/: leds.c
software components: CMSIS:CORE 5.0.1
