# Keil uVision project Project.uvprojx, settings and files
target STM32_Nucleo_WMBus-Meter-868MHz (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152RE-Nucleo_wM-Bus_Meter +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_STM32L1XX_NUCLEO,STM32L152xx,NO_EEPROM,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT,STM32L152xE
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\..\Drivers\STM32L1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L1xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc;..\..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\AES_Encr\inc;..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\link\inc;..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013\phy\inc;..\..\..\..\..\..\Middlewares\ST\WMBUS_Library_2013
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../../Src/: cube_hal_l1.c main.c radio_hal.c stm32l1xx_it.c SDK_EVAL_Timers.c wmbus_tim.c
  group Docs
    ../../: readme.txt
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/BSP/STM32L1xx_NUCLEO
    ../../../../../../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/BSP/Spirit1_Driver/SPIRIT1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l1xx.c
  group Middlewares/ST/WMBUS_Library/Appli/Src
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/AES_Encr/src/: aes.c wmbus_cbc.c
  group Middleware/ST/WMBUS_Library/Link
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/link/src/: wmbus_crc.c wmbus_linkcommand.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c
  group Drivers/BSP/Spirit1_Driver/SPIRIT1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group wM-Bus_Library
    ../../../../../../Middlewares/ST/WMBUS_Library_2013/Library/: SPIRIT1_wMBus_Library242_CM3_Keil.lib
