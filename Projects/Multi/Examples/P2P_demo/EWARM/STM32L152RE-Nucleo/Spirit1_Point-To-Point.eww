<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Spirit1_Point-To-Point.ewp</path>
  </project>
  <batchBuild/>
</workspace>


