# Keil uVision project P2P_Demo.uvprojx, settings and files
target Spirit1-Point-To- Point (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L053R8-Nucleo_P2P +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER,STM32L053xx,NO_EEPROM,P2P_DEMO,SPIRIT1_ST_SHIELD,USE_SPIRIT1_DEFAULT
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDS01Ax\Inc;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Library\Inc;..\..\..\..\..\..\Drivers\BSP\Components\spirit1\SPIRIT1_Util\Inc;..\..\..\..\..\..\..\Utilities
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../../Src/: cube_hal_l0.c main.c spirit1_appli.c stm32l0xx_it.c
  group Docs
    ../../: readme.txt
  group Drivers/BSP/Components/spirit1/Spirit1_Driver/Spirit1_Util
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Util/Src/: SPIRIT1_Util.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDS01Ax
    ../../../../../../Drivers/BSP/X-NUCLEO-IDS01Ax/Src/: radio_gpio.c radio_shield_config.c radio_spi.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/BSP/Components/spirit1/Spirit1_Library
    ../../../../../../Drivers/BSP/Components/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_wwdg.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dma.c stm32l0xx_hal_adc.c
